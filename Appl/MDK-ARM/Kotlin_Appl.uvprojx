# Keil uVision project Kotlin_Appl.uvprojx, settings and files
target Kotlin_Appl (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Kotlin_Appl
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Drivers/CMSIS/Include;        ../Middlewares/vscp-framework/vscp;        ../Src/vscp_user;        ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;        ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x17000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c timers.c event_groups.c tasks.c croutine.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/vscp-framework
    ../Middlewares/vscp-framework/vscp/: vscp_core.c vscp_data_coding.c vscp_dev_data.c vscp_dm.c vscp_dm_ng.c vscp_logger.c vscp_ps.c vscp_transport.c vscp_util.c
    ../Middlewares/vscp-framework/vscp/templates/: vscp_action.c vscp_app_reg.c
    ../Middlewares/vscp-framework/vscp/events/: vscp_alarm.c vscp_control.c vscp_information.c vscp_log.c vscp_measurement.c vscp_measurezone.c vscp_security.c vscp_weather.c vscp_weather_forecast.c
  group Application/vscp_user
    ../Src/vscp_user/: vscp_portable.c vscp_ps_access.c vscp_tp_adapter.c vscp_timer.c
  group Application/User
    ../Src/: eeprom.c eeprom_layout.c usbd_conf.c usart.c freertos.c usbd_desc.c usb_device.c spi.c usbd_cdc_if.c stm32f1xx_it.c gpio.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_hal_msp.c main.c can.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_can.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_spi.c stm32f1xx_hal_pcd.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.1.0
